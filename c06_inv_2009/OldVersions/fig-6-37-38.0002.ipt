# Autodesk Inventor part: fig5-29a
## iProperties
Created: 2005-12
Part Number: fig5-29a
Document SubType Name: Modeling
Designer: CADCIM
Author: CADCIM
## Feature names
1. Extrusion1
