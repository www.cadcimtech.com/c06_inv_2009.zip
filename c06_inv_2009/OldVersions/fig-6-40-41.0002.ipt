# Autodesk Inventor part: fig5-33
## iProperties
Created: 2005-12
Part Number: fig5-33
Document SubType Name: Modeling
Designer: CADCIM
Author: CADCIM
## Feature names
1. Extrusion1
